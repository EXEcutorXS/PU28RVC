# Keil uVision project PU-28.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303CC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PU-28 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin Objects\PU-28.axf --output PU-28.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c misc: --cpp  --diag_suppress 174
  c include: .\User\Activity\Setup clock;.\User\Activity\Setup;.\User\Activity\Sleep;.\User\Activity\Start timers;.\User\Activity\Work;.\User\VisualObjects\Checkbox;.\User\VisualObjects\Slider;.\User\Main;.\User\VisualObjects\Clock;.\User\VisualObjects\Start timer;.\User\Activity\Boot;.\User\Temperature;.\User\Memory;.\User\Display;.\User\Sensor;.\User\Font;.\User\Canvas;.\User\Text;.\User\Activity\System;.\User\Activity\Search;.\User\Activity\Error;.\User\Activity\About;.\User\Can;.\User\Time;.\User\Bluetooth;.\User\Activity\Ble connect
  memory RVCT4: ROM 0x800c000 size 0x31000
  memory RVCT5: ROM 0x803d000 size 0x3000
  memory RVCT9: RAM 0x20000000 size 0xbffc
  group Activity
    ./User/Main/: main.cpp
    ./User/Activity/Search/: search.cpp
    ./User/Activity/Error/: error.cpp
    ./User/Activity/System/: system.cpp
    ./User/Activity/Sleep/: sleep.cpp
    ./User/Activity/Start timers/: start_timers.cpp
    ./User/Activity/Setup/: setup.cpp
    ./User/Activity/Setup clock/: setup_clock.cpp
    ./User/Activity/About/: about.cpp
    ./User/Text/: text.cpp
    ./: Version.txt Memory Map.txt
    ./User/Activity/Ble connect/: ble_connect.cpp
  group VisualObjects
    ./User/VisualObjects/Checkbox/: checkbox.cpp
    ./User/VisualObjects/Clock/: clock.cpp
    ./User/VisualObjects/Slider/: slider.cpp
    ./User/VisualObjects/Start timer/: start_timer.cpp
  group Drivers
    ./User/Main/: core.cpp
    ./User/Canvas/: canvas.cpp
    ./User/Can/: can.cpp rvc.cpp pgn_rvc.cpp gd32f30x_can.c
    ./User/Temperature/: temperature.cpp
    ./User/Memory/: memory.cpp
    ./User/Display/: display.cpp
    ./User/Sensor/: sensor.cpp
    ./User/Font/: font.c
    ./User/Time/: unix_time.cpp
    ./User/Bluetooth/: bluetooth.cpp
  group Usart
    ./User/Main/: hcu.cpp usart.cpp
software components: CMSIS:CORE 5.0.1, Device:GD32F30x_StdPeripherals:ADC 1.0.2, Device:GD32F30x_StdPeripherals:BKP 1.0.2, Device:GD32F30x_StdPeripherals:CRC 1.0.2, Device:GD32F30x_StdPeripherals:CTC 1.0.2, Device:GD32F30x_StdPeripherals:DAC 1.0.2, Device:GD32F30x_StdPeripherals:DBG 1.0.2, Device:GD32F30x_StdPeripherals:DMA 1.0.2, Device:GD32F30x_StdPeripherals:ENET 1.0.2, Device:GD32F30x_StdPeripherals:EXMC 1.0.2, Device:GD32F30x_StdPeripherals:EXTI 1.0.2, Device:GD32F30x_StdPeripherals:FMC 1.0.2, Device:GD32F30x_StdPeripherals:FWDGT 1.0.2, Device:GD32F30x_StdPeripherals:GPIO 1.0.2, Device:GD32F30x_StdPeripherals:I2C 1.0.2, Device:GD32F30x_StdPeripherals:MISC 1.0.2, Device:GD32F30x_StdPeripherals:PMU 1.0.2, Device:GD32F30x_StdPeripherals:RCU 1.0.2, Device:GD32F30x_StdPeripherals:RTC 1.0.2, Device:GD32F30x_StdPeripherals:SDIO 1.0.2, Device:GD32F30x_StdPeripherals:SPI_I2S 1.0.2, Device:GD32F30x_StdPeripherals:TIMER 1.0.2, Device:GD32F30x_StdPeripherals:USART 1.0.2, Device:GD32F30x_StdPeripherals:WWDGT 1.0.2, Device:GD32F30x_libopt 1.0.2, Device:Startup 1.0.2
